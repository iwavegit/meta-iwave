SRCREV_opencv = "f70f223ea33a62e8d8a03f8a0de33f6b7b2f2bb3"
